# Keil uVision project Project.uvprojx, settings and files
target Target (6220000::V6.22::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Dimmer-Fan-TuyaCompat +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F002Ax5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f002xx.s
  group Application/User
    ../Src/: main.c uart.c py32f0xx_it.c settings.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_gpio.c py32f0xx_ll_rcc.c py32f0xx_ll_usart.c py32f0xx_ll_tim.c py32f0xx_ll_exti.c
  group Doc
    ../: readme.txt
